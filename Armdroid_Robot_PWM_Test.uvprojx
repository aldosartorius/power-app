# Keil uVision project Armdroid_Robot_PWM_Test.uvprojx, settings and files
target STM32F401RE (6240000::V6.24::ARMCLANG)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Armdroid_Robot_PWM_Test +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F401xE
  c include: C:\Users\aldo_\AppData\Local\Arm\Packs\Keil\STM32F4xx_DFP\2.17.1\Drivers\CMSIS\Device\ST\STM32F4xx\Include;C:\Users\aldo_\AppData\Local\Arm\Packs\ARM\CMSIS\6.3.0\CMSIS\Core\Include;..\HAL_STM32F401\HAL_GPIO;..\HAL_STM32F401\HAL_TIM;..\HAL_STM32F401\HAL_UART
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group app
    ../HAL_STM32F401/HAL_GPIO/: stm32f4xx_hal_gpio.h stm32f4xx_hal_gpio.c
    ../HAL_STM32F401/HAL_TIM/: stm32f4xx_hal_tim.h stm32f4xx_hal_tim.c
    ../HAL_STM32F401/HAL_UART/: stm32f4xx_hal_uart.h stm32f4xx_hal_uart.c
    ./: app_config.h crc8.h pc_frame.h ringbuf.h system.h arbiter.c crc8.c motor.c pc_frame.c system.c main.c stm32f4xx_hal_gpio_cfg.c stm32f4xx_hal_tim_cfg.c stm32f4xx_hal_uart_cfg.c stm32f4xx_hal_gpio_cfg.h stm32f4xx_hal_tim_cfg.h stm32f4xx_hal_uart_cfg.h arbiter.h motor.h ringbuf.c
  group startup
    C:/Users/aldo_/AppData/Local/Arm/Packs/Keil/STM32F4xx_DFP/2.17.1/Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    C:/Users/aldo_/AppData/Local/Arm/Packs/Keil/STM32F4xx_DFP/2.17.1/Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f401xe.s
software components: CMSIS:CORE 6.2.0
